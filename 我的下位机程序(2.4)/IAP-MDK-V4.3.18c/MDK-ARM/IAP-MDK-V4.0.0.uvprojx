# Keil uVision project IAP-MDK-V4.0.0.uvprojx, settings and files
target IAP-MDK-V4.0.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP-MDK-V4.0.0 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG
  c include: ../Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                   ../Drivers/CMSIS/Include;                   ..\app;                   ..\Middlewares\ethernet;                   ..\Middlewares\PLC;                   ..\Middlewares\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/APP
    ../app/: app_exti.c app_tim.c app_usart.c app_user.c app_i2c.c app_can.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Middlewares/PLC
    ../Middlewares/PLC/: plc_user.c plc_flow.c plc_modbus.c plc_input.c plc_switch.c plc_beep.c plc_delay.c plc_button.c plc_eep.c plc_can.c plc_test.c plc_bridge.c plc_motor.c
  group Middlewares/modbus
    ../Middlewares/modbus/: mb_user.c mb_port.c mb_cb.c mb_serial.c mb_timer.c mb_rtu.c mb_ascii.c mb_tcp.c mb_func_holding.c mb_utils.c mb_crc.c mb_err.c mb_master.c
  group Middlewares/ethernet
    ../Middlewares/ethernet/: eth_user.c eth_socket.c eth_spi.c eth_type.c eth_w5500.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
